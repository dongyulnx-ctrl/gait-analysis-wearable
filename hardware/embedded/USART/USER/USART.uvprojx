# Keil uVision project USART.uvprojx, settings and files
target USART (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CMSIS;..\FWLib\inc;..\BSP;..\BSP\Delay;..\BSP\Usart1;..\BSP\Timer;..\BSP\mcu_model
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c AllHeader.h myenum.h imu_feature.c emg_feature.c fusion_send.c
  group CMSIS
    ../CMSIS/: system_stm32f10x.c core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ../BSP/Delay/: delay.c
    ../BSP/: bsp.c
    ../BSP/Usart1/: usart.c
    ../BSP/Timer/: bsp_timer.c
    ../BSP/mcu_model/: imu_uart_driver.c
    ./: emg_uart.c adc.c adc.h
